# Keil uVision project TIMER.uvproj, settings and files
target TIMER (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: TIMER +hex
  AfterMake: fromelf.exe --bin -o ./obj/Timer.bin ./obj/TIMER.axf
  c flags: Optim=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_StdPeriph_Driver\inc;..\STM32F10x_StdPeriph_Driver\CMSIS\CoreSupport;..\STM32F10x_StdPeriph_Driver\CMSIS\DeviceSupport;..\User\Main;..\User\Main\hmlib;..\User\Main\hmlib\include;..\User\Main\com_inc;..\lwip-1.3.1\port;..\lwip-1.3.1\src\include;..\lwip-1.3.1\src\include\ipv4;..\lwip-1.3.1\src\include\lwip;..\STM32_ETH_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../User/Main/: main.c stm32f10x_it.c netconf.c server.c stm32f107.c
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_flash.c misc.c stm32f10x_tim.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_iwdg.c
  group CMSIS
    ../STM32F10x_StdPeriph_Driver/CMSIS/CoreSupport/: core_cm3.c
    ../STM32F10x_StdPeriph_Driver/CMSIS/DeviceSupport/: system_stm32f10x.c
    ../STM32F10x_StdPeriph_Driver/CMSIS/DeviceSupport/Startup/: startup_stm32f10x_cl.s
  group DOC
    ../Doc/: information.txt
  group hmlib
    ../User/Main/hmlib/: hm_timer.c hm_msg_queue.c hm_msg_queue.h hm_step_motor.h hm_step_motor.c hm_uart.c hm_cmd_execute.c hm_step_motor_limit_operation.c hm_cmd_inter_netwk.c hm_cmd_inter_uart.c hm_gpio.c hm_gpio.h hm_cmd_execute.h hm_cmd_inter_netwk.h hm_cmd_inter_uart.h hm_step_motor_defs.h hm_step_motor_hw_config.h hm_step_motor_limit_operation.h hm_timer.h hm_uart.h hm_led.c hm_address.c hm_address.h hm_iwdg.c hm_iwdg.h hm_temperature.c hm_debug.h hm_debug_private.h
    ../User/Main/com_inc/: hm_sw_version.h
  group STM32_ETH_Driver
    ../STM32_ETH_Driver/src/: stm32_eth.c
    ../STM32_ETH_Driver/inc/: stm32_eth.h
  group LWIP
    ../lwip-1.3.1/port/: ethernetif.c
    ../lwip-1.3.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c
    ../lwip-1.3.1/src/core/: dhcp.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip-1.3.1/src/netif/: etharp.c
